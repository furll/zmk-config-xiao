## boards/shields/xiao_keypad/Kconfig.defconfig
```kconfig
if SHIELD_XIAO_KEYPAD

config ZMK_KEYBOARD_NAME
    default "Xiao Keypad"

endif
```
